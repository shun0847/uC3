SRCBRANCH ?= "master"
SRCREV ?= "3c223735ea969199b3c9e2e2a85c9fa7c022b6c0"
LIC_FILES_CHKSUM ?= "file://LICENSE.md;md5=a8d8cf662ef6bf9936a1e1413585ecbf"

include open-amp.inc
